# IAR project blink.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105C6; STM8S105
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: blink.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S105C6; STM8S105
  ICCSTM8.CCIncludePath2: ..\..\..\..\stm8\stm8af_stm8s
  ILINK.IlinkOutputFile: blink.out
  group (top)
    ../: main.c
  group includes
    ../../../../stm8/stm8af_stm8s/: STM8AF_STM8S.h STM8S105C6.h STM8S105K6.h
  group SPL
    ../: stm8s.h stm8s_conf.h stm8s_gpio.c stm8s_gpio.h stm8s_it.c stm8s_it.h stm8s_tim4.c stm8s_tim4.h
